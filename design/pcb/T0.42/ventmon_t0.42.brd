# Repository OpenICU-org/ventmon-ventilator-inline-test-monitor

## EAGLE design design/pcb/T0.42/ventmon_t0.42.brd

Parts:
C1, C2, C3, C4, C5, C6, C9, C10, C17: 0.1uF; C0402_B
C7, C8: 18pF; C0402_B
C11: 100nF; C0402_B
C12, C13: 6.8nF; C0402_B
C14, C26: 10nF; C0402_B
C15: 1n/2KV; C-1808
C16: 4.7uF; 0603
C22, C23: 10uF; 0603
D1: RED; LED-0603
J1: CONN_03; 1X03
J2, J3: CONN_02; 1X02
L2: INDUCTOR-0805-3.3UH; 0805
R2: 10K; R0402_B
R6: 12.4k 1%; R0402_B
R8: 1M; R0402_B
R10, R11, R13, R14: 49R9 1%; R0402_B
R12: 10R 1%; R0402_B
R17: 0R; R0402_B
R20, R21: 10k; R0402_B
R22, R23: 330R; R0402_B
R24: 1k; R0402_B
R34, R35, R36, R37: 33R; R0402_B
RN1, RN2: 10k; 4X0402ARV341
T1: WE-RJ45_7499210121A; 7499210121A
U1: W5500
Y1: 25MHz; CRYSTAL-SMD-3.2X2.5MM

Connections:
!INTN: R20.1, U1.36 (INT_N); also elsewhere on the board
!RESET: C10.2, R2.1, U1.37 (RST_N); also elsewhere on the board
+3V3: C9.2, C17.2, C22.1, D1.A, L2.1, R2.2, R20.2, R21.2, RN2.2 (1), RN2.3 (1), RN2.4 (1), T1.11 (LED1_Y+), T1.13 (LED2_G+), U1.28 (VDD); also elsewhere on the board
+3V3A: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C23.1, L2.2, R10.2, R11.2, R12.2, U1.4 (AVDD), U1.8 (AVDD), U1.11 (AVDD), U1.15 (AVDD), U1.17 (AVDD), U1.21 (AVDD)
+5V: J1.1; also elsewhere on the board
ACTLED: R23.2, U1.27 (ACTLED)
CHGND: C15.P$1, T1.Z1 (SHIELD1), T1.Z2 (SHIELD2)
G-: R22.1, T1.14 (LED2_G-)
GND: C1.1, C2.1, C3.1, C4.1, C5.1, C6.1, C7.1, C8.1, C9.1, C10.1, C11.1, C14.1, C15.P$2, C16.2, C17.1, C22.2, C23.2, C26.1, J1.2, J1.3, J2.1, J2.2, R6.1, R24.1, RN1.1, RN1.2 (1), RN1.3 (1), RN1.4 (1), RN2.1, U1.3 (AGND), U1.9 (AGND), U1.14 (AGND), U1.16 (AGND), U1.19 (AGND), U1.23 (RSVD), U1.29 (GND), U1.48 (AGND), Y1.2 (3), Y1.4 (3); also elsewhere on the board
LINKLED: R22.2, U1.25 (LINKLED)
MISO: U1.34 (MISO); also elsewhere on the board
MOSI: U1.35 (MOSI); also elsewhere on the board
unnamed: RN2.7 (2), U1.43 (PMODE2)
unnamed: RN2.6 (2), U1.44 (PMODE1)
unnamed: RN2.5 (2), U1.45 (PMODE0)
unnamed: RN1.8 (2), U1.38 (RSVD)
unnamed: RN1.7 (2), U1.39 (RSVD)
unnamed: RN1.6 (2), U1.40 (RSVD)
unnamed: RN1.5 (2), U1.41 (RSVD)
unnamed: RN2.8 (2), U1.42 (RSVD)
unnamed: C8.2, R17.1, Y1.1
unnamed: C16.1, U1.20 (TOCAP)
unnamed: C26.2, U1.22 (1V2O)
unnamed: R6.2, U1.10 (EXRES1)
unnamed: D1.C, R24.2
unnamed: R8.1, R17.2, U1.31 (XO)
unnamed: C7.2, R8.2, U1.30 (XI/CLKIN), Y1.3 (2)
RCT: C14.2, R13.1, R14.1, T1.3 (CRD)
RD+: C12.2, T1.1 (RD+)
RD-: C13.2, T1.2 (RD-)
RX_N: C13.1, R14.2, R37.1
RX_P: C12.1, R13.2, R36.1
R_N: R37.2, U1.5 (RXN)
R_P: R36.2, U1.6 (RXP)
SCLK: U1.33 (SCLK); also elsewhere on the board
SCSN: R21.1, U1.32 (SCS_N); also elsewhere on the board
TCT: C11.2, R12.1, T1.4 (CTD)
TD+: R11.1, R34.1, T1.5 (TD+)
TD-: R10.1, R35.1, T1.6 (TD-)
T_N: R35.2, U1.1 (TXN)
T_P: R34.2, U1.2 (TXP)
V+: J3.2, T1.9 (V+)
V-: J3.1, T1.10 (V-)
Y-: R23.1, T1.12 (LED1_Y-)

Notes on the sheet:
To PoE module
From PoE module

Parts:
C18: 1µF; 0805
C19, C21: 0.1uF; C0402_B
D2: DIODE-BAS16J; SOD-323
FIO2: 87438-02
FLOW: 87438-04
H1, H2, H3, H4: MOUNT-HOLE2.8; 2,8
IC1: BME280BM280-HAT; BME280-HAT
J4: CONN_04POLAR; MOLEX-1X4
J6: Header-16; 1X16
J7: Header-12; 1X12
JP1, JP2, JP3: JUMPER-SMT_2_NC_TRACE_NO-SILK; SMT-JUMPER_2_NC_TRACE_NO-SILK
OLED: 87438-04
PRESSURE1: HSCDRRT001PD2A3; DIP1330W46P254L1000H616Q8B
R1, R3: 4.7K; 0805
R4, R5, R7, R9, R15, R16, R18: 10K; 0805
U2: ADS1115IDGST; MSOP10

Connections:
!INTN: JP2.2; also elsewhere on the board
!RESET: D2.A, JP3.2; also elsewhere on the board
+3V3: C18.2, C19.2, C21.2, IC1.2 (CSB), IC1.6 (VDD), IC1.8 (VDDIO), J4.2, J6.2, OLED.2, PRESSURE1.2 (VS), R1.1, R3.1, R5.1, R7.1, R9.1, R15.1, U2.8 (VDD); also elsewhere on the board
+5V: FLOW.2, J7.3; also elsewhere on the board
ADDR: R4.1, U2.1 (ADDR)
ALERT: R5.2, U2.2 (ALERT)
BTNA: J4.4, J7.4, R18.2
BTNB: J4.3, J7.5, R16.2
FIO2: FIO2.2, U2.7 (AIN3)
GND: C18.1, C19.1, C21.1, FIO2.1, FLOW.1, IC1.1 (GND), IC1.5 (SDO), IC1.7 (GND), J4.1, J6.4, OLED.1, PRESSURE1.1 (GND), R4.2, R16.1, R18.1, U2.3 (GND); also elsewhere on the board
MISO: J6.13; also elsewhere on the board
MOSI: J6.12; also elsewhere on the board
unnamed: D2.C, J6.1
unnamed: J7.7, JP1.1
unnamed: J7.8, JP2.1
unnamed: J7.9, JP3.1
unnamed: R7.2, U2.6 (AIN2)
unnamed: R9.2, U2.5 (AIN1)
unnamed: R15.2, U2.4 (AIN0)
SCL: FLOW.4, IC1.4 (SCK), J7.11, OLED.4, PRESSURE1.4 (SCL), R1.2, U2.10 (SCL)
SCLK: J6.11; also elsewhere on the board
SCSN: JP1.2; also elsewhere on the board
SDA: FLOW.3, IC1.3 (SDI), J7.12, OLED.3, PRESSURE1.3 (SDA), R3.2, U2.9 (SDA)

Notes on the sheet:
Default I²C Address = 1001000
For I2C leave CSB pulled high (default value) SDI=SDA, SCK=SCL

Board: 2 copper layers, 75.0 x 56.1 mm, 77 parts (3 on the bottom side), 58 nets.

## Commit log

2020-12-01 Updated VentMon PCB to V0.4
2020-12-01 Commited pro file
2020-12-02 Fixed missing 3v3 wire, added groundplane, fixed DRC errors
2020-12-15 Moved pressure sensors to accomodate small tube
2020-12-16 Reduced board width to from 85mm to 75mm to fit in case.

Notices in the files:
parts and their libraries:
SparkFun-Coils: Licensing: Creative Commons ShareAlike 4.0 International - https://creativecommons.org/licenses/by-sa/4.0
Wurth_Signal: Copyright: Würth Elektronik
